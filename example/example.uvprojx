# Keil uVision project example.uvprojx, settings and files
target example_arm_compiler_6 (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: example +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=2
  c define: __PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__,__PERFC_STACK_CHECK_IN_ISR__,__PERFC_STACK_GROWS_UPWARD__
  c include: ..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: example.sct
  group application
    ./: stdout_USART.c main.c platform.c pt_example.c cpt_example.c
  group perf_counter_lib
    ../: perf_counter.c perf_counter.h systick_wrapper_ual.s perfc_port_default.c perfc_port_default.h
target library (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: perf_counter (library)
  AfterMake: copy.bat
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=2
  c misc: -Wno-undef
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: Blinky.sct
target example_arm compiler_5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: example
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: __PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\example.sct
software components: CMSIS Driver:Ethernet:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:CORE 6.1.0, Device:Startup 2.2.0, Device:Startup 2.2.0, Language Extension:Coroutine 1.0.0, Language Extension:protoThread 1.1.0, Utilities:perf_counter:Core 2.5.2-dev, Compiler:I/O:STDOUT 1.2.0
